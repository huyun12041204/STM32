<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\H743_Cat.ewp</path>
  </project>
  <batchBuild />
</workspace>
